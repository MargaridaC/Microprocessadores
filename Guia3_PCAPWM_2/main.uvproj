# Keil uVision project main.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F388 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0x0000-0x0FFF) IROM(0-0xFFFF) CLOCK(48000000)
  output: main
  c flags: SizeSpeed=1
  group Source Group 1
    ./: main.c init.h init.c buttons.h buttons.c uart.h uart.c pca.h pca.c interpeter.h interpeter.c
