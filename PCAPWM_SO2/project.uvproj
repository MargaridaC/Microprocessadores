# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F388 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0x0000-0x0FFF) IROM(0-0xFFFF) CLOCK(48000000)
  output: project
  c flags: SizeSpeed=1
  group Source Group 1
    ./: main.c debounce.c debounce.h uart.c uart.h InitDev.c InitDev.h
